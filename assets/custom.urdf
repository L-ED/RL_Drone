Commit message: stable

File: assets/custom.urdf (robot description, URDF)
Before this commit: robot cf2, 6 links, 5 joints
Links:
- link base_link: mass 0.027 -> 0.725977; geometry collision box size=.32 .35 .05; visual mesh filename=./drone_normal_zup.obj scale=0.001 0.001 0.001
