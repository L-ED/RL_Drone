Commit message: state and cam bugfix

File: gym_pybullet_drones/assets/cf2x_cam.urdf (robot description, URDF)
Before this commit: robot cf2, 7 links, 6 joints
Links:
- link cam_link: geometry visual mesh filename=./foxeer_razor_nano.stl scale=0.001 0.001 0.001
